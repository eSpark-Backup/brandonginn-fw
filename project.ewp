# IAR project project.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2541F128 CC2541F128
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Projects\ble\include
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F128_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    C:/Texas Instruments/BLE-CC254x-1.5.2.0/Components/hal/target/CC2540EB/: hal_uart.c
    ./: main.c
  group HAL Files
    C:/Texas Instruments/BLE-CC254x-1.5.2.0/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_aes.h hal_board_cfg.h hal_ccm.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_flash.c hal_led.c hal_mcu.h hal_startup.c hal_timer.c hal_types.h
