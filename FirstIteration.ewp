# IAR project FirstIteration.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2541F128 CC2541F128
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.PreInclude: C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\target\CC2541ST\hal_types.h
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\target\CC2541ST; C:\Texas Instruments\BLE-CC254x-1.5.2.0\Components\hal\common
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group user
    ./: main.c
